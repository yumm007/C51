# Keil uVision project C51.uvproj, settings and files
target C51 (MCS-51)
  device: AT89C55 Atmel
  cpu: IRAM(0 - 0xFF) IROM(0 - 0x4FFF) CLOCK(24000000)
  output: C51 +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: .\Lib;
  group User
    ./: STARTUP.A51 hello.c
  group Lib
    ./Lib/: i2c.h usart.c usart.h i2c.c spi.c spi.h lib.c lib.h
